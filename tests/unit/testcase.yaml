## tests/unit/testcase.yaml
```yaml
tests:
  sensor_node.unit:
    platform_allow:
      - native_sim
    tags: unit
```
